# Keil uVision project Project.uvprojx, settings and files
target SENSING1_HAR_GMP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SENSING1 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,STM32_SENSORTILE,PRIORITY_RTOS,ARM_MATH_CM4,__FPU_PRESENT=1,NN_GMP
  c misc: --no_conditionalize --diag_suppress 1
  c include: ..\..\Inc;..\..\Patch;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\SensorTile;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsm;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\stc3115;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ./: startup_stm32l476xx.s
  group User
    ../../Src/: HWAdvanceFeatures.c main.c OTA.c PowerControl.c sensor_service.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c DataLog_Manager.c sd_diskio_SensorTile.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_MAG_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_ACC_driver.c
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
  group Drivers/BSP/SensorTile
    ../../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_accelero.c SensorTile_audio_in.c SensorTile_BlueNRG.c SensorTile_gg.c SensorTile_gyro.c SensorTile_humidity.c SensorTile_magneto.c SensorTile_pressure.c SensorTile_sd.c SensorTile_temperature.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx-Nucleo
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c
  group Middlewares/STM32_MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/ST/STM32_BlueNRG
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c osal.c ble_list.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/Portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Third_Party/FreeRTOS/TracePerception
    ../../../../../../Utilities/TraceRecorder/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group User_Patch
    ../../Patch/: bluenrg_gap_aci_patch.c bluenrg_hal_aci_patch.c bluenrg_utils_small_patch.c hci_patch.c SensorTile_BlueNRG_patch.c SensorTile_humidity_patch.c SensorTile_pressure_patch.c SensorTile_temperature_patch.c
  group Middlewares/ST/STM32_USB_Device_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/ST/STM32_AI_Library
    ../../../../../../Middlewares/ST/STM32_AI_Library/Lib/: NetworkRuntime330_CM4_Keil.lib
  group Middlewares/ST/STM32_AI_Library/GMP_HAR
    ../../../../../../Middlewares/ST/STM32_AI_Library/HAR_GMP/Src/: network.c network_data.c
  group Middlewares/ST/STM32_AI_Library/IGN_HAR
    ../../../../../../Middlewares/ST/STM32_AI_Library/HAR_IGN/Src/: network.c network_data.c
  group Middlewares/ST/STM32_AI_Library/IGN_WSDM_HAR
    ../../../../../../Middlewares/ST/STM32_AI_Library/HAR_IGN_WSDM/Src/: network.c network_data.c
  group Middlewares/ST/STM32_AI_Library/ASC
    ../../../../../../Middlewares/ST/STM32_AI_Library/ASC/Src/: network.c network_data.c
  group User_Har
    ../../Src/: har_Postprocessing.c har_Preprocessing.c har_Processing.c har_ProcessingTest.c
  group User_Asc
    ../../Src/: asc.c asc_preprocessing.c asym_hann_win_1024.c mel_filters_lut_30.c usbd_audio_if.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio_template.c
target SENSING1_HAR_IGN (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: as above
  output: SENSING1 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,STM32_SENSORTILE,PRIORITY_RTOS,ARM_MATH_CM4,__FPU_PRESENT=1,NN_IGN
  c misc: --no_conditionalize --diag_suppress 1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
target SENSING1_HAR_IGN_WSDM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: as above
  output: SENSING1 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,STM32_SENSORTILE,PRIORITY_RTOS,ARM_MATH_CM4,__FPU_PRESENT=1,NN_IGN_WSDM
  c misc: --no_conditionalize --diag_suppress 1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
target SENSING1_ASC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: as above
  output: SENSING1 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,STM32_SENSORTILE,PRIORITY_RTOS,ARM_MATH_CM4,__FPU_PRESENT=1,NN_ASC
  c misc: --no_conditionalize --diag_suppress 1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329  --diag_suppress L6989
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2
