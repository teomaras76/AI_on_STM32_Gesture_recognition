# IAR project Project.ewp, settings and files
configuration STM32L476RG-SensorTile HAR_GMP (ARM)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; STM32_SENSORTILE; PRIORITY_RTOS; NN_GMP
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Patch; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsm; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\..\Drivers\BSP\SensorTile; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\stc3115; ..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\..\Middlewares\ST\Matteo\Gesture
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: SENSING1.bin
  ILINK.IlinkOutputFile: SENSING1_ST.out
  ILINK.IlinkIcfFile: stm32l476xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L476RG-SensorTile HAR_IGN (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; STM32_SENSORTILE; PRIORITY_RTOS; NN_IGN
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Patch; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsm; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\..\Drivers\BSP\SensorTile; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\stc3115; ..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
configuration STM32L476RG-SensorTile HAR_IGN_WSDM (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; STM32_SENSORTILE; PRIORITY_RTOS; NN_IGN_WSDM
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
configuration STM32L476RG-SensorTile ASC (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; STM32_SENSORTILE; PRIORITY_RTOS; NN_ASC
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Patch; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsm; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\..\Drivers\BSP\SensorTile; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\stc3115; ..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
  group Drivers/BSP/SensorTile
    ../../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_accelero.c SensorTile_audio_in.c SensorTile_BlueNRG.c SensorTile_gg.c SensorTile_gyro.c SensorTile_humidity.c SensorTile_magneto.c SensorTile_pressure.c SensorTile_sd.c SensorTile_temperature.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx-Nucleo
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio_template.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_AI_Library
    ../../../../../../Middlewares/ST/STM32_AI_Library/Lib/: NetworkRuntime330_CM4_IAR.a
  group Middlewares/STM32_AI_Library/ASC
    ../../../../../../Middlewares/ST/STM32_AI_Library/ASC/Src/: network.c network_data.c
  group Middlewares/STM32_AI_Library/Gesture
    ../../../../../../Middlewares/Matteo/Gesture/: network.c network_data.c
  group Middlewares/STM32_AI_Library/GMP_HAR
    ../../../../../../Middlewares/ST/STM32_AI_Library/HAR_GMP/Src/: network.c network_data.c
  group Middlewares/STM32_AI_Library/IGN_HAR
    ../../../../../../Middlewares/ST/STM32_AI_Library/HAR_IGN/Src/: network.c network_data.c
  group Middlewares/STM32_AI_Library/IGN_WSDM_HAR
    ../../../../../../Middlewares/ST/STM32_AI_Library/HAR_IGN_WSDM/Src/: network.c network_data.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/STM32_BlueNRG/HCI/Controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group SENSING1/EWARM
    ./: startup_stm32l476xx.s
  group SENSING1/User
    ../../Src/: DataLog_Manager.c HWAdvanceFeatures.c main.c OTA.c PowerControl.c sd_diskio_SensorTile.c sensor_service.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group SENSING1/User/Asc
    ../../Src/: asc.c asc_preprocessing.c asym_hann_win_1024.c mel_filters_lut_30.c usbd_audio_if.c
  group SENSING1/User/Gesture
    ../../Src/: gesture_Postprocessing.c gesture_Preprocessing.c gesture_Processing.c gesture_ProcessingTest.c
  group SENSING1/User/Patch
    ../../Patch/: bluenrg_gap_aci_patch.c bluenrg_hal_aci_patch.c bluenrg_utils_small_patch.c hci_patch.c SensorTile_BlueNRG_patch.c SensorTile_humidity_patch.c SensorTile_pressure_patch.c SensorTile_temperature_patch.c
